# Keil uVision project STM32H573I_DK_OSPI.uvprojx, settings and files
target STM32H573I_DK_OSPI (6210000::V6.21::ARMCLANG)
  device: STM32H573IITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.4.0-RC5
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MX25LM51245G_STM32H573I-DK
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM,USE_HAL_DRIVER,USE_IOEXPANDER, CORE_CM33,STM32H573xx
  c include: .\Inc;..\..\..\Drivers\BSP\STM32H573I-DK;..\..\..\Drivers\BSP\Components\mx25lm51245g;..\..\..\Drivers\STM32H5xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32H5xx\Include;..\..\..\Drivers\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./src/: STM32H5OSPI.c
  group STM32H5xx_HAL_Driver
    ../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c
  group BSP/STM32H573I-DK
    ../../../Drivers/BSP/STM32H573I-DK/: stm32h573i_discovery_ospi.c
  group BSP/Components
    ../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group CMSIS/STM32H5xx
    ../../../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
